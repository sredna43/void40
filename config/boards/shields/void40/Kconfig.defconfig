## config/boards/shields/void40/Kconfig.defconfig
```kconfig
if SHIELD_VOID40

config ZMK_KEYBOARD_NAME
	default "Void40"

config CONFIG_CLOCK_CONTROL=y

endif
```
